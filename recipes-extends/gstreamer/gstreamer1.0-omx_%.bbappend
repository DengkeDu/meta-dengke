GSTREAMER_1_0_OMX_TARGET = "rpi"
GSTREAMER_1_0_OMX_CORE_NAME ?= "${libdir}/libomxil-rpi.so.0"
